Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-08T16:44:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 08 16:44:26 2023 * Host: DESKTOP-DGNAOIQ * Database: C:\Users\Usuario\AppData\Local\Temp\080f4935-69c4-4197-8030-021d1fc060be\e633bdf2-17cf-48f6-8c77-99264267b077\ifc * Database version: 5507 * Database creation date: Wed Mar 08 16:44:22 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 08 16:44:24 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 08 16:44:24 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 m

# IfcFurnishingElement: Luminaria Isabelina Ilis:Luminaria Isabelina-ILIS-485mm, Luminaria Isabelina Ilis:Luminaria Isabelina-ILIS-485mm:511623
In: Level 1
Type - Material: Aluminio
Type - PRODUCT_PROPERTIES - 02 Material: Aluminio; 03 Dimension_H: 0.87 m; 03 Dimension_H1: 0.555 m; 03 Dimension_B: 0.485 m; 04 Descripción: La Luminaria Clásica que pertenece a la familia de las Fernandinas; 05 Información_Adicional: Isabelina de tipología Ornamental incorpora todos los detalles técnicos necesarios para la tecnología LED; 06 Referencia: ILIS; 07 URL_Producto: https://www.benito.com/es/alumbrado-publico/clasicas/isabelina--ILIS.html?gclid=Cj0KCQiAgaGgBhC8ARIsAAAyLfETraIb51F301KL_bOP7RA0WDBn90PD6_N9dZbS9fEAb_vySQmXSzgaAu0LEALw_wcB; 08 Ficha_Técnica: https://www.benito.com/es/download/data-sheet-ILIS; 09 Fabricante: BENITO URBAN SL
Material: Aluminio, Glass, <Unnamed>
PRODUCT_PROPERTIES - 01 Producto: Luminaria Isabelina Ilis: Luminaria Isabelina-ILIS-485mm
